v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {full_adder_1bit.sym} 600 0 0 0 {name=X0}
C {lab_pin.sym} 500 -50 0 0 {name=l1 sig_type=std_logic lab=A0}
C {lab_pin.sym} 500 -10 0 0 {name=l2 sig_type=std_logic lab=B0}
C {lab_pin.sym} 500 30 0 0 {name=l3 sig_type=std_logic lab=Cin}
C {lab_pin.sym} 700 -50 2 0 {name=l4 sig_type=std_logic lab=S0}
C {lab_pin.sym} 700 -10 2 0 {name=l5 sig_type=std_logic lab=c1}
C {lab_pin.sym} 600 -100 3 0 {name=l6 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 600 100 1 0 {name=l7 sig_type=std_logic lab=GND}
C {full_adder_1bit.sym} 600 400 0 0 {name=X1}
C {lab_pin.sym} 500 350 0 0 {name=l8 sig_type=std_logic lab=A1}
C {lab_pin.sym} 500 390 0 0 {name=l9 sig_type=std_logic lab=B1}
C {lab_pin.sym} 500 430 0 0 {name=l10 sig_type=std_logic lab=c1}
C {lab_pin.sym} 700 350 2 0 {name=l11 sig_type=std_logic lab=S1}
C {lab_pin.sym} 700 390 2 0 {name=l12 sig_type=std_logic lab=c2}
C {lab_pin.sym} 600 300 3 0 {name=l13 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 600 500 1 0 {name=l14 sig_type=std_logic lab=GND}
C {full_adder_1bit.sym} 600 800 0 0 {name=X2}
C {lab_pin.sym} 500 750 0 0 {name=l15 sig_type=std_logic lab=A2}
C {lab_pin.sym} 500 790 0 0 {name=l16 sig_type=std_logic lab=B2}
C {lab_pin.sym} 500 830 0 0 {name=l17 sig_type=std_logic lab=c2}
C {lab_pin.sym} 700 750 2 0 {name=l18 sig_type=std_logic lab=S2}
C {lab_pin.sym} 700 790 2 0 {name=l19 sig_type=std_logic lab=c3}
C {lab_pin.sym} 600 700 3 0 {name=l20 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 600 900 1 0 {name=l21 sig_type=std_logic lab=GND}
C {full_adder_1bit.sym} 600 1200 0 0 {name=X3}
C {lab_pin.sym} 500 1150 0 0 {name=l22 sig_type=std_logic lab=A3}
C {lab_pin.sym} 500 1190 0 0 {name=l23 sig_type=std_logic lab=B3}
C {lab_pin.sym} 500 1230 0 0 {name=l24 sig_type=std_logic lab=c3}
C {lab_pin.sym} 700 1150 2 0 {name=l25 sig_type=std_logic lab=S3}
C {lab_pin.sym} 700 1190 2 0 {name=l26 sig_type=std_logic lab=Cout}
C {lab_pin.sym} 600 1100 3 0 {name=l27 sig_type=std_logic lab=VDD}
C {lab_pin.sym} 600 1300 1 0 {name=l28 sig_type=std_logic lab=GND}
C {ipin.sym} 0 0 0 0 {name=pi0 lab=A0}
C {ipin.sym} 0 50 0 0 {name=pi1 lab=A1}
C {ipin.sym} 0 100 0 0 {name=pi2 lab=A2}
C {ipin.sym} 0 150 0 0 {name=pi3 lab=A3}
C {ipin.sym} 0 200 0 0 {name=pi4 lab=B0}
C {ipin.sym} 0 250 0 0 {name=pi5 lab=B1}
C {ipin.sym} 0 300 0 0 {name=pi6 lab=B2}
C {ipin.sym} 0 350 0 0 {name=pi7 lab=B3}
C {ipin.sym} 0 400 0 0 {name=pi8 lab=Cin}
C {opin.sym} 0 600 0 0 {name=po0 lab=S0}
C {opin.sym} 0 650 0 0 {name=po1 lab=S1}
C {opin.sym} 0 700 0 0 {name=po2 lab=S2}
C {opin.sym} 0 750 0 0 {name=po3 lab=S3}
C {opin.sym} 0 800 0 0 {name=po4 lab=Cout}
C {iopin.sym} 0 900 0 0 {name=pv1 lab=VDD}
C {iopin.sym} 0 950 0 0 {name=pv2 lab=GND}
